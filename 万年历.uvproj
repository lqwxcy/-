# Keil uVision project 万年历.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 万年历 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: delay.c LCD12864.c ds1302.c timeadjust.c keyscan.c keypro.c disfestival.c ds18b20.c ds18b20alarm.c ds18b20distemp.c main.c
  group head
    ./src/: timeadjust.h config.h delay.h disfestival.h ds18b20.h ds18b20alarm.h ds18b20distemp.h ds1302.h keypro.h keyscan.h LCD12864.h
